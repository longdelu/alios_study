# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx OTA_SIGNAL_CHANNEL
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SDRAM;..\HARDWARE\TIMER;..\HARDWARE\IIC;..\HARDWARE\PCF8574;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MALLOC;..\iotkit-embedded\src\log;..\iotkit-embedded\src\mqtt;..\iotkit-embedded\src\mqtt\MQTTPacket;..\iotkit-embedded\src\coap;..\iotkit-embedded\src\packages\iot-coap-c;..\iotkit-embedded\src\guider;..\iotkit-embedded\src\ota;..\iotkit-embedded\src\platform\os\freertos;..\iotkit-embedded\src\platform\ssl\freertos-mbedtls;..\iotkit-embedded\src\platform\ssl\freertos-openssl;..\iotkit-embedded\src\shadow;..\iotkit-embedded\src\system;..\iotkit-embedded\sample;..\iotkit-embedded\sample\coap;..\iotkit-embedded\sample\mqtt;..\iotkit-embedded\sample\http;..\iotkit-embedded\sample\device-shadow;..\iotkit-embedded\sample\ota;..\iotkit-embedded\src\utils\digest;..\iotkit-embedded\src\utils\misc;..\iotkit-embedded\src\utils\LITE-log;..\iotkit-embedded\src\utils\LITE-utils;..\iotkit-embedded\src\sdk-impl;..\iotkit-embedded\src\sdk-impl\exports;..\iotkit-embedded\src\sdk-impl\imports;..\iotkit-embedded\src\tfs;..\iotkit-embedded\src\platform\ssl\freertos_mbedtls_include;..\iotkit-embedded\src\utils\cjson\include;..\iotkit-embedded\src\utils\digest_algorithm;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include;..\LWIP\arch;..\LWIP\lwip_app\lwip_comm;..\LWIP;..\HARDWARE\LAN8720
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_eth.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LAN8720/: lan8720.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: readme.txt
  group AliYun
    ../iotkit-embedded/src/utils/misc/: utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
    ../iotkit-embedded/src/utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
    ../iotkit-embedded/src/utils/LITE-utils/: json_parser.c json_token.c lite-utils_testsuites.c mem_stats.c string_utils.c
    ../iotkit-embedded/src/utils/LITE-log/: lite-log.c
    ../iotkit-embedded/src/sdk-impl/: sdk-impl.c
    ../iotkit-embedded/src/system/: ca.c device.c report.c
    ../iotkit-embedded/src/guider/: guider.c id2_guider.c
    ../iotkit-embedded/src/http/: iotx_http_api.c
    ../iotkit-embedded/src/ota/: ota.c
    ../iotkit-embedded/src/coap/: iotx_ca_cert.c iotx_coap_api.c
    ../iotkit-embedded/src/packages/iot-coap-c/: CoAPDeserialize.c CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPSerialize.c
    ../iotkit-embedded/src/shadow/: shadow.c shadow_common.c shadow_delta.c shadow_update.c
    ../iotkit-embedded/src/mqtt/: mqtt_client.c
    ../iotkit-embedded/src/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
    ../iotkit-embedded/src/platform/os/freertos/: hal_os_freertos.c hal_tcp_freertos.c hal_udp_freertos.c
    ../iotkit-embedded/src/platform/ssl/freertos-mbedtls/: HAL_DTLS_mbedtls.c HAL_TLS_mbedtls.c
    ../iotkit-embedded/src/platform/ssl/freertos-openssl/: HAL_TLS_openssl.c
    ../iotkit-embedded/src/utils/cjson/: cJSON.c
    ../iotkit-embedded/src/utils/digest_algorithm/: CheckSumUtils.c md5.c
  group AliYun_Example
    ../iotkit-embedded/sample/coap/: coap-example.c
    ../iotkit-embedded/sample/device-shadow/: shadow-example.c
    ../iotkit-embedded/sample/http/: http-example.c
    ../iotkit-embedded/sample/mqtt/: mqtt-example.c mqtt_rrpc-example.c
    ../iotkit-embedded/sample/ota/: ota_coap-example.c ota_mqtt-example.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
